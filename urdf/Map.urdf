Commit message: fix name

File: urdf/Map.urdf (robot description, URDF)
Before this commit: robot Map, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=package://robocon2023_map/meshes/base_link.STL; visual mesh filename=package://robocon2023_map/meshes/base_link.STL
